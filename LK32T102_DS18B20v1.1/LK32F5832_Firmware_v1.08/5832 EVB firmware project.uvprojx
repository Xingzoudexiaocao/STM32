# Keil uVision project 5832 EVB firmware project.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SC32F5832 SILAN
  pack: Keil.SC32F5832_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 5832 EVB firmware project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\headers;D:\Program Files (x86)\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;.\USER;.\RTE\Device\SC32F5832
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SRC
    ./SRC/: ADC.c CLK.c ETIMER.c main.c PWM.c GPIO.c IRQ.c ISR.c Uart0.c Uart1.c DevInit.c CMP.c OPA.c DMA.c IAP.c WDT.c
  group headers
    ./headers/: ADC.h CLK.h PWM.h GPIO.h ETIMER.h UART.h DevInit.h CMP.h OPA.h DMA.h Coproc.h IAP.h Datatype.h
  group user
    ./USER/: keyboard4x4.c delay.c ds18b20.c printf.c LCD12864.c
  group core
    ./RTE/Device/SC32F5832/: startup_SC32F5832.s system_SC32F5832.c
software components: CMSIS:CORE 5.0.1
